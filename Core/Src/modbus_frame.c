/**
 * @file modbus_frame.c
 * @brief Modbus RTU frame parser and builder — pure C99, zero HAL dependency.
 */

#include "modbus_frame.h"

/* -------------------------------------------------------------------------
 * CRC-16 lookup tables (standard Modbus polynomial 0xA001)
 * ---------------------------------------------------------------------- */

static const uint8_t crc_hi[] = {
    0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,
    0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,
    0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,
    0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,
    0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,
    0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,
    0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,
    0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,
    0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,
    0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,
    0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,
    0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,
    0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,
    0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,
    0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40,0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,
    0x00,0xC1,0x81,0x40,0x01,0xC0,0x80,0x41,0x01,0xC0,0x80,0x41,0x00,0xC1,0x81,0x40
};

static const uint8_t crc_lo[] = {
    0x00,0xC0,0xC1,0x01,0xC3,0x03,0x02,0xC2,0xC6,0x06,0x07,0xC7,0x05,0xC5,0xC4,0x04,
    0xCC,0x0C,0x0D,0xCD,0x0F,0xCF,0xCE,0x0E,0x0A,0xCA,0xCB,0x0B,0xC9,0x09,0x08,0xC8,
    0xD8,0x18,0x19,0xD9,0x1B,0xDB,0xDA,0x1A,0x1E,0xDE,0xDF,0x1F,0xDD,0x1D,0x1C,0xDC,
    0x14,0xD4,0xD5,0x15,0xD7,0x17,0x16,0xD6,0xD2,0x12,0x13,0xD3,0x11,0xD1,0xD0,0x10,
    0xF0,0x30,0x31,0xF1,0x33,0xF3,0xF2,0x32,0x36,0xF6,0xF7,0x37,0xF5,0x35,0x34,0xF4,
    0x3C,0xFC,0xFD,0x3D,0xFF,0x3F,0x3E,0xFE,0xFA,0x3A,0x3B,0xFB,0x39,0xF9,0xF8,0x38,
    0x28,0xE8,0xE9,0x29,0xEB,0x2B,0x2A,0xEA,0xEE,0x2E,0x2F,0xEF,0x2D,0xED,0xEC,0x2C,
    0xE4,0x24,0x25,0xE5,0x27,0xE7,0xE6,0x26,0x22,0xE2,0xE3,0x23,0xE1,0x21,0x20,0xE0,
    0xA0,0x60,0x61,0xA1,0x63,0xA3,0xA2,0x62,0x66,0xA6,0xA7,0x67,0xA5,0x65,0x64,0xA4,
    0x6C,0xAC,0xAD,0x6D,0xAF,0x6F,0x6E,0xAE,0xAA,0x6A,0x6B,0xAB,0x69,0xA9,0xA8,0x68,
    0x78,0xB8,0xB9,0x79,0xBB,0x7B,0x7A,0xBA,0xBE,0x7E,0x7F,0xBF,0x7D,0xBD,0xBC,0x7C,
    0xB4,0x74,0x75,0xB5,0x77,0xB7,0xB6,0x76,0x72,0xB2,0xB3,0x73,0xB1,0x71,0x70,0xB0,
    0x50,0x90,0x91,0x51,0x93,0x53,0x52,0x92,0x96,0x56,0x57,0x97,0x55,0x95,0x54,0x94,
    0x9C,0x5C,0x5D,0x9D,0x5F,0x9F,0x9E,0x5E,0x5A,0x9A,0x9B,0x5B,0x99,0x59,0x58,0x98,
    0x88,0x48,0x49,0x89,0x4B,0x8B,0x8A,0x4A,0x4E,0x8E,0x8F,0x4F,0x8D,0x4D,0x4C,0x8C,
    0x44,0x84,0x85,0x45,0x87,0x47,0x46,0x86,0x82,0x42,0x43,0x83,0x41,0x81,0x80,0x40
};

/* -------------------------------------------------------------------------
 * Modbus exception codes
 * ---------------------------------------------------------------------- */
#define EX_ILLEGAL_FUNCTION      0x01
#define EX_ILLEGAL_DATA_ADDRESS  0x02
#define EX_ILLEGAL_DATA_VALUE    0x03

/* -------------------------------------------------------------------------
 * Internal helpers
 * ---------------------------------------------------------------------- */

static void append_crc(uint8_t *buf, uint16_t len, uint16_t *out_len)
{
    uint16_t crc = Modbus_CRC16(buf, len);
    Modbus_Register_t r;
    r.U16 = crc;
    buf[len]     = r.U8[0];
    buf[len + 1] = r.U8[1];
    *out_len = len + 2;
}

static void build_exception(uint8_t slave_addr, uint8_t func_code,
                             uint8_t ex_code,
                             uint8_t *tx_buf, uint16_t *tx_len)
{
    tx_buf[0] = slave_addr;
    tx_buf[1] = func_code | 0x80;
    tx_buf[2] = ex_code;
    append_crc(tx_buf, 3, tx_len);
}

/* FC03 — Read Holding Registers */
static void fc03_read(Modbus_Frame_Ctx_t *ctx,
                      const uint8_t *pdu,   /* pdu[0]=FC, [1..2]=addr, [3..4]=count */
                      uint8_t *tx_buf, uint16_t *tx_len)
{
    uint16_t addr  = ((uint16_t)pdu[1] << 8) | pdu[2];
    uint16_t count = ((uint16_t)pdu[3] << 8) | pdu[4];

    if (count < 1 || count > 0x7D) {
        build_exception(ctx->slave_address, 0x03, EX_ILLEGAL_DATA_VALUE, tx_buf, tx_len);
        return;
    }
    if (addr + count > ctx->register_count) {
        build_exception(ctx->slave_address, 0x03, EX_ILLEGAL_DATA_ADDRESS, tx_buf, tx_len);
        return;
    }

    tx_buf[0] = ctx->slave_address;
    tx_buf[1] = 0x03;
    tx_buf[2] = (uint8_t)(2 * count);
    for (uint16_t i = 0; i < count; i++) {
        tx_buf[3 + i * 2]     = ctx->registers[addr + i].U8[1]; /* hi byte */
        tx_buf[3 + i * 2 + 1] = ctx->registers[addr + i].U8[0]; /* lo byte */
    }
    append_crc(tx_buf, 3 + 2 * count, tx_len);
}

/* FC06 — Write Single Register */
static void fc06_write(Modbus_Frame_Ctx_t *ctx,
                       const uint8_t *pdu,
                       uint8_t *tx_buf, uint16_t *tx_len)
{
    uint16_t addr = ((uint16_t)pdu[1] << 8) | pdu[2];

    if (addr >= ctx->register_count) {
        build_exception(ctx->slave_address, 0x06, EX_ILLEGAL_DATA_ADDRESS, tx_buf, tx_len);
        return;
    }

    ctx->registers[addr].U8[1] = pdu[3]; /* hi byte from master */
    ctx->registers[addr].U8[0] = pdu[4]; /* lo byte from master */

    /* Echo back the request (standard FC06 response) */
    tx_buf[0] = ctx->slave_address;
    memcpy(&tx_buf[1], &pdu[0], 5);
    append_crc(tx_buf, 6, tx_len);
}

/* FC16 — Write Multiple Registers */
static void fc16_write_multiple(Modbus_Frame_Ctx_t *ctx,
                                const uint8_t *pdu, uint16_t pdu_len,
                                uint8_t *tx_buf, uint16_t *tx_len)
{
    /* Minimum: FC(1) + start_addr(2) + quantity(2) + byte_count(1) = 6 bytes */
    if (pdu_len < 6) {
        build_exception(ctx->slave_address, 0x10, EX_ILLEGAL_DATA_VALUE, tx_buf, tx_len);
        return;
    }

    uint16_t addr     = ((uint16_t)pdu[1] << 8) | pdu[2];
    uint16_t quantity = ((uint16_t)pdu[3] << 8) | pdu[4];
    uint8_t  byte_cnt = pdu[5];

    if (quantity < 1 || quantity > 0x7B) {
        build_exception(ctx->slave_address, 0x10, EX_ILLEGAL_DATA_VALUE, tx_buf, tx_len);
        return;
    }
    if (byte_cnt != (uint8_t)(quantity * 2)) {
        build_exception(ctx->slave_address, 0x10, EX_ILLEGAL_DATA_VALUE, tx_buf, tx_len);
        return;
    }
    if ((uint16_t)(6u + byte_cnt) > pdu_len) {
        build_exception(ctx->slave_address, 0x10, EX_ILLEGAL_DATA_VALUE, tx_buf, tx_len);
        return;
    }
    if (addr + quantity > ctx->register_count) {
        build_exception(ctx->slave_address, 0x10, EX_ILLEGAL_DATA_ADDRESS, tx_buf, tx_len);
        return;
    }

    for (uint16_t i = 0; i < quantity; i++) {
        ctx->registers[addr + i].U8[1] = pdu[6 + i * 2];     /* hi byte */
        ctx->registers[addr + i].U8[0] = pdu[6 + i * 2 + 1]; /* lo byte */
    }

    /* Response: slave + FC + start_addr(2) + quantity(2) + CRC(2) = 8 bytes */
    tx_buf[0] = ctx->slave_address;
    tx_buf[1] = 0x10;
    tx_buf[2] = pdu[1];
    tx_buf[3] = pdu[2];
    tx_buf[4] = pdu[3];
    tx_buf[5] = pdu[4];
    append_crc(tx_buf, 6, tx_len);
}

/* -------------------------------------------------------------------------
 * Public API
 * ---------------------------------------------------------------------- */

uint16_t Modbus_CRC16(const uint8_t *data, uint16_t len)
{
    uint8_t hi = 0xFF, lo = 0xFF;
    while (len--) {
        uint8_t idx = lo ^ *data++;
        lo = hi ^ crc_hi[idx];
        hi = crc_lo[idx];
    }
    return ((uint16_t)hi << 8) | lo;
}

bool Modbus_BuildResponse(Modbus_Frame_Ctx_t *ctx,
                          const uint8_t *rx_buf, uint16_t rx_len,
                          uint8_t       *tx_buf, uint16_t *tx_len)
{
    *tx_len = 0;

    /* Minimum frame: addr(1) + FC(1) + data(1) + CRC(2) = 5 bytes
     * FC03/FC06 PDU is at least 5 bytes, so total >= 8. Accept >= 4 for exceptions. */
    if (rx_len < 4) return false;

    /* Verify CRC (last 2 bytes) */
    uint16_t crc_calc = Modbus_CRC16(rx_buf, rx_len - 2);
    Modbus_Register_t crc_wire;
    crc_wire.U8[0] = rx_buf[rx_len - 2];
    crc_wire.U8[1] = rx_buf[rx_len - 1];
    if (crc_calc != crc_wire.U16) return false;

    /* Check slave address */
    if (rx_buf[0] != ctx->slave_address) return false;

    /* Dispatch on function code (PDU starts at rx_buf[1]) */
    const uint8_t *pdu     = &rx_buf[1];
    uint16_t       pdu_len = rx_len - 3u; /* strip slave_addr(1) + CRC(2) */
    switch (pdu[0]) {
        case 0x03: fc03_read          (ctx, pdu,          tx_buf, tx_len); break;
        case 0x06: fc06_write         (ctx, pdu,          tx_buf, tx_len); break;
        case 0x10: fc16_write_multiple(ctx, pdu, pdu_len, tx_buf, tx_len); break;
        default:
            build_exception(ctx->slave_address, pdu[0],
                            EX_ILLEGAL_FUNCTION, tx_buf, tx_len);
            break;
    }
    return true;
}
